# Repository davidphilipbarr/5plice

## KiCad design 5plice.kicad_pcb

Board: 2 copper layers, 99.8 x 80.7 mm, 23 parts (3 on the bottom side), 22 nets.

Parts:
Bat+1: MountingHole_Pad; 1pin_conn
BatGND1: MountingHole_Pad; 1pin_conn
RSW1: SW_Push; ResetSW
SW2, SW3, SW4, SW5, SW6, SW8, SW9, SW10, SW11, SW12, SW14, SW15, SW16, SW17, SW18, SW20, SW21, SW21#2: SW_Push; SW_PG1350_rev_DPB
SW_POWER1: SW_SPDT; SPDT_C128955
U1: ProMicro-kbd; ProMicro_v2_1side

Connections:
BT+: Bat+1.1, SW_POWER1.2
Switch1: SW2.1, U1.9
Switch2: SW3.1, U1.17
Switch3: SW4.1, U1.18
Switch4: SW5.1, U1.19
Switch5: SW6.1, U1.20
Switch6: SW8.1, U1.16
Switch7: SW9.1, U1.15
Switch8: SW10.1, U1.14
Switch9: SW11.1, U1.13
Switch10: SW12.1, U1.1
Switch11: SW14.1, U1.5
Switch12: SW15.1, U1.6
Switch13: SW16.1, U1.7
Switch14: SW17.1, U1.8
Switch15: SW18.1, U1.10
Switch16: SW20.1, U1.11
Switch17: SW21.1, U1.12
Switch18: SW21#2.1, U1.2
gnd: BatGND1.1, RSW1.1, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2, SW20.2, SW21.2, SW21#2.2, U1.3, U1.4, U1.23
raw: SW_POWER1.3, U1.24
reset: RSW1.2, U1.22
